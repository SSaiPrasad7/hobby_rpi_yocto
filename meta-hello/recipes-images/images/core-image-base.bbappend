IMAGE_INSTALL += " hello chardrv"