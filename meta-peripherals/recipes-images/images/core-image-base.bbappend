IMAGE_INSTALL += " gpio"
